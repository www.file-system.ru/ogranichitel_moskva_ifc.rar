Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Номер проекта
Time: 2018-01-15T12:42:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.0.490.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 15 12:42:33 2018 * Host: DESKTOP-9RIKPKU * Database: C:\Users\voins\AppData\Local\Temp\{C973A9C3-A3E7-4662-9823-660526505732}\ifc * Database version: 5507 * Database creation date: Mon Jan 15 12:42:32 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 15 12:42:33 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 15 12:42:33 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Номер проекта
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 45, 25, 90026; RefLongitude: 37, 36, 54, 74707; RefElevation: 0 mm
Прочее - Адрес проекта: Укажите адрес; Дата утверждения проекта: Дата выпуска; Заказчик: Владелец; Категория: Сведения о проекте; Наименование проекта: Наименование проекта; Номер проекта: Номер проекта; Статус проекта: Статус проекта

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Прочее - Категория: Сведения о проекте; Адрес проекта: Укажите адрес; Дата утверждения проекта: Дата выпуска; Заказчик: Владелец; Наименование проекта: Наименование проекта; Номер проекта: Номер проекта; Статус проекта: Статус проекта

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Верхний брус 8 мм; Семейство: Уровень: Верхний брус 8 мм; Семейство и типоразмер: Уровень: Верхний брус 8 мм; Тип: Уровень: Верхний брус 8 мм
Идентификация - Имя типа: Верхний брус 8 мм; Имя: Уровень 1; Несущие конструкции: no; Построение этажа: yes
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: Заголовок уровня - Окружность: Заголовок уровня - Окружность; Образец линий: Центр; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: no; Цвет: 0

# IfcBuildingElementProxy: "Москва" Черный шелк, ogranichitel_moskva:"Москва" Черный шелк:409975
In: Уровень 1
Type - Material: Очаковский_Черный_шелк
Type - Данные - Объем бетона: 0.083 m3
Type - Идентификация - Имя типа: "Москва" Черный шелк
Type - Материалы и отделка - Материал: Очаковский_Черный_шелк
Type - Прочее - Категория: Антураж; Имя семейства: ogranichitel_moskva
Type - Размеры - Высота: 500 mm; Длина: 500 mm; Ширина: 500 mm
Type - Текст - Наименование: Ограничитель "Москва"; Производитель: ГК Очаковский комбинат ЖБИ
Pset_BuildingElementProxyCommon - Reference: "Москва" Черный шелк
Данные - Водонепроницаемость: W8; Защитное покрытие: 0.786; Класс бетона: В30; Масса: 38; Морозостойкость: F150; Площадь: 1.156 m2
Зависимости - Основа: Уровень : Уровень 1; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Уровень 1
Прочее - Длина.Верх: 300 mm; Код типа: ogranichitel_moskva: "Москва" Черный шелк; Семейство: ogranichitel_moskva: "Москва" Черный шелк; Семейство и типоразмер: ogranichitel_moskva: "Москва" Черный шелк; Тип: ogranichitel_moskva: "Москва" Черный шелк; Ширина.Верх: 300 mm
Размеры - Объем: 0.125 m3; Площадь: 0.75 m2
Стадии - Стадия возведения: Новая конструкция
Текст - Описание изделия: Вазон «Твист» изготовлен по новейшей бесшовной технологии и имеет необычную форму, позволяющую отойти от строгих прямых линий, характерных для изделий из бетона.Компактность вазона позволит использовать его в условиях ограниченного пространства,а интересная форма никого не оставит равнодушным.
